## boards/shields/retro68/Kconfig.defconfig
```kconfig
if SHIELD_RETRO68

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Retro68"

endif
```
